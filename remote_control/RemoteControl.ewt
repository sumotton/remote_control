<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\stm32f10x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\stm32f10x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\stm32f10x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\App\stm32f10x_it.h</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <group>
      <name>StartUp</name>
      <file>
        <name>$PROJ_DIR$\CMSIS\StartUp\startup_stm32f10x_cl.s</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\CMSIS\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f10x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\CMSIS\system_stm32f10x.h</name>
    </file>
  </group>
  <group>
    <name>FWLib</name>
    <group>
      <name>Inc</name>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_bkp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_cec.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_crc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_dbgmcu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_fsmc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_sdio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\inc\stm32f10x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>Src</name>
      <file>
        <name>$PROJ_DIR$\FwLib\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_cec.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_fsmc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\FwLib\src\stm32f10x_wwdg.c</name>
      </file>
    </group>
  </group>
</project>


